# Keil uVision project oledANDmax30100.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: oledANDmax30100 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Lib;..\Lib\inc;..\Lib\src;..\sourses
  group Lib
    ./: STARTUP.A51
    ../Lib/inc/: common.h IIC.h oled.h MAX30100.h
    ../Lib/src/: common.c IIC.c oled.c MAX30100.c ONboardIIC.c Uart.c
  group app
    ./: main.c
    ../sourses/: Display.c bmp.h Display.h Timer.c
